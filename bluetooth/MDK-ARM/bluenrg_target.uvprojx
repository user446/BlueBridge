# Keil uVision project bluenrg_target.uvprojx, settings and files
target Server (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: BlueNRG-2 STMicroelectronics
  pack: Keil.STBlueNRG-2_DFP.1.0.1
  cpu: IRAM(0x20000000,0x6000) IROM(0x10040000,0x40000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: BlueCardio_server +hex
  AfterMake: fromelf.exe --bin Objects\BlueCardio_server.axf --output Objects\BlueCardio_server.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: LS_SOURCE=LS_SOURCE_EXTERNAL_32KHZ SMPS_INDUCTOR=SMPS_INDUCTOR_10uH UART_BAUDRATE=115200 HS_SPEED_XTAL=HS_SPEED_XTAL_16MHZ USER_BUTTON=BUTTON_1 BLE_STACK_CONFIGURATION=BLE_STACK_FULL_CONFIGURATION BLUENRG2_DEVICE SERVER=1
  c include: ..\inc;..\Library\hal\inc;..\Library\BlueNRG1_Periph_Driver\inc;..\Library\CMSIS\Device\ST\BlueNRG1\Include;..\Library\CMSIS\Include;..\Library\Bluetooth_LE\inc;..\Library\BLE_Application\layers_inc;..\Library\BLE_Application\Utils\inc;..\Library\BLE_Application\OTA\inc;..\Library\SDK_Eval_BlueNRG1\inc;..\src\s25fl256lib;..\src\s25fl256lib\targets
  asm misc: --cpreproc
  library: MicroLIB
  memory RVCT4: ROM 0x10040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x6000
  scatter file: .\BlueNRG2.sct
  group HAL
    ../Library/hal/src/: clock.c context_switch.s gp_timer.c miscutil.c osal.c sleep.c
  group Library
    ../Library/BlueNRG1_Periph_Driver/src/: BlueNRG1_adc.c BlueNRG1_dma.c BlueNRG1_flash.c BlueNRG1_gpio.c BlueNRG1_i2c.c BlueNRG1_mft.c BlueNRG1_pka.c BlueNRG1_radio.c BlueNRG1_rng.c BlueNRG1_rtc.c BlueNRG1_spi.c BlueNRG1_sysCtrl.c BlueNRG1_uart.c BlueNRG1_wdg.c misc.c
  group Platform_Layers
    ../Library/SDK_Eval_BlueNRG1/src/: SDK_EVAL_Config.c SDK_EVAL_Com.c SDK_EVAL_Button.c SDK_EVAL_Led.c
  group Stack
    ../Library/Bluetooth_LE/src/: stack_user_cfg.c
    ../Library/Bluetooth_LE/library/: libbluenrg1_stack.a
    ../Library/cryptolib/: libcrypto.a
  group Startup
    ../Library/CMSIS/Device/ST/BlueNRG1/Source/: system_bluenrg1.c
  group User
    ../src/: BlueNRG1_it.c gatt_db.c throughput.c main.c queue.c
    ../inc/: queue.h
target Client (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: BlueNRG-2 STMicroelectronics
  pack: Keil.STBlueNRG-2_DFP.1.0.1
  cpu: as above
  output: BlueBridge +hex
  AfterMake: fromelf.exe --bin Objects\BlueBridge.axf --output Objects\BlueBridge.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: LS_SOURCE=LS_SOURCE_INTERNAL_RO SMPS_INDUCTORSMPS_INDUCTOR_NONE HS_SPEED_XTAL=HS_SPEED_XTAL_16MHZ UART_BAUDRATE=115200 USER_BUTTON=BUTTON_1 BLE_STACK_CONFIGURATION=BLE_STACK_FULL_CONFIGURATION BLUENRG2_DEVICE CLIENT=1
  c include: as above
  asm misc: --cpreproc
  library: MicroLIB
  memory RVCT4: ROM 0x10040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x6000
  scatter file: .\BlueNRG2.sct
